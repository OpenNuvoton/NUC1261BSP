# Keil uVision project USBD_CCID.uvproj, settings and files
target USBD_CCID (6190000::V6.19::ARMCLANG)
  device: NUC1261SG4AE Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x3FFFF) CLOCK(72000000) CPUTYPE("Cortex-M0")
  output: USBD_CCID
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC1261\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\SmartcardLib\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC1261.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC1261/Source/: system_NUC1261.c
    ../../../../Library/Device/Nuvoton/NUC1261/Source/ARM/: startup_NUC1261.s
  group User
    ../: main.c ccid.c Ccid_if.c descriptors.c sc_intf.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c sc.c usbd.c
    ../../../../Library/SmartcardLib/: SmartCardLib_Keil.lib
